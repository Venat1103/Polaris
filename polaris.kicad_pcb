# Repository Venat1103/Polaris

File README.md:

# Polaris
Open source flight computer

## States
- ### Boot
  - Starts all the peripherals and calibrates
  - No data logging

- ### Failure Diagnosis
  - Check in which state failure happened by:
    - checking data coming from barometers
    - checking continuity
    - checking gps
  - If `altitude = constant`
    - `motor pyro = continuous` => SAFE (not ARMED)
    - `motor pyro = discontinuous` => RECOVERY
  - If `altitude = increasing`
    - `acceleration > g` => BOOST
    - `acceleration < g` => COAST
  - If `altitude = decreasing`
    - `drogue pyro = continuous` => DROGUE
    - `main pyro = discontinuous` => MAIN
  - By looking at data, transfers to the appropriate state which could be anything from safe to recovery

- ### Safe
  - Transmit telemetry
- ### Armed
  - Log data
- ### Boost
  - Fire both motor pyro charges
- ### Coast
- ### Drogue
  - Fire both drogue chute pyro charges
- ### Early Main
  - Drogue chute deployment failed, fire both main chute pyro charges earlier than nominal (1500 feet)
- ### Main
  - Fire both main chute pyro charges
- ### Recovery
  - Turns off all sensors except for gps
  - Transmit only gps

## Transitions
- ### Boot to Failure Diagnosis
  Check what caused the microcontroller reset, if anything other
  than power-on reset or reset button, go to `FAILURE DIAGNOSIS`
- ### Boot to Safe
  Check what caused the microcontroller reset, if power-on reset
  or reset button, go to `SAFE`

- ### Failure Diagnosis to Safe
  - `altitude = constant`
  - `motor pyro = continuous`
- ### Failure Diagnosis to Recovery
  - `altitude = constant`
  - `motor pyro = discontinous`
- ### Failure Diagnosis to Boost
  - `altitude = increasing`
  - `vertical acceleration = positive`
- ### Failure Diagnosis to Coast
  - `altitude = increasing`
  - `vertical acceleration = -g`
- ### Failure Diagnosis to Drogue
  - `altitude = decreasing`
  - `vertical acceleration > -g`
- ### Failure Diagnosis to Early Main
  - `altitude = decreasing`
  - `altitude < [early main deployment altitude]`
  - `vertical acceleration = -g`
- ### Failure Diagnosis to Main
  - `altitude = decreasing`
  - `altitude < [main deployment altitude]`
  - `vertical acceleration > -g`

- ### Safe to Armed
  - if ground station sends ARMED command
- ### Armed to Boost
  - if ground station sends FIRE command
- ### Boost to Coast
  - if acceleration goes from +ve to -ve
- ### Coast to Drogue
  - Apogee detection
- ### Drogue to Early Main
  - if acceleration is still g, even though drogue chutes were supposedly deployed, it means that drogue chutes failed
  - altitude < early main chute deployment altitude (>1500 feet)
- ### Drogue to Main
  - altitude < main chute deployment altitude (1500 feet)
- ### Early Main to Recovery
  - huge change in vertical acceleration
  - altitude = constant
- ### Main to Recovery
  - huge change in vertical acceleration
  - altitude = constant

## Modules
- ### STM32 F446 VE Tx `MICROCONTROLLER`
- ### ICM 42688 P `IMU 0` - SPI 1

    | Function | Description | GPIO | Pin Mode
    |-|-|-|-|
    SCK | Clock | PA 5 | AF 5
    MOSI | Master Out | PA 7 | AF 5
    MISO | Master In | PA 6 | AF 5
    NSS | Slave Select | PA 4 | AF 5
    INT | Interrupt | PA 3 | Input

- ### LSM 6DSO 3 `IMU 1` - SPI 2

    | Function | Description | GPIO | Pin Mode
    |-|-|-|-|
    SCK | Clock | PB 13 | AF 5
    MOSI | Master Out | PC 1 | AF 7
    MISO | Master In | PC 2 | AF 5
    INT | Interrupt | PB 12 | Input

- ### MS 5607 02 BA 03 `BARO 0` - I2C 1

    | Function | Description | GPIO | Pin Mode | Pin Type
    |-|-|-|-|-|
    SCL | Clock | PB 8 | AF 4 | Open Drain
    SDA | Data | PB 7 | AF 4 | Open Drain

- ### LPS 22 HHTR `BARO 1` - I2C 3

    | Function | Description | GPIO | Pin Mode | Pin Type
    |-|-|-|-|-|
    SCL | Clock | PA 8 | AF 4 | Open Drain
    SDA | Data | PC 9 | AF 4 | Open Drain
    INT | Interrupt | PA 9 | Input

- ### Quectel L89HA `GNSS` - USART 4

    | Function | Description | GPIO | Pin Mode
    |-|-|-|-|
    TX | Transmit | PA 0 | AF 8
    RX | Receive | PA 1 | AF 8

- ### Ra-01SH SX1262 `RF` - USART 5

    | Function | Description | GPIO | Pin Mode
    |-|-|-|-|
    TX | Transmit | PE 8 | AF 8
    RX | Receive | PE 7 | AF 8

- ### PC 817 `OPTOCOUPLER` (x6) + IRL Z44 N `MOSFET` (x6)

    | Function | GPIO | Pin Mode
    |-|-|-|
    Main 0 | PD 9 | Output
    Main 1 | PD 10 | Output
    Drogue 0 | PD 14 | Output
    Drogue 1 | PD 15 | Output
    Fire 0 | PC 6 | Output
    Fire 1 | PC 7 | Output

- ### 32.768 kHz Crystal `RTC` - RCC OSC 32

    | Function | Description | GPIO |
    |-|-|-|
    RCC OSC IN | Oscillator In | PH 0
    RCC OSC OUT | Oscillator Out | PH 1

- ### Servos `ACTUATION`

    | Function | Description | GPIO | Pin Mode
    |-|-|-|-|
    Servo S0 | TIM12 CH1 | PB 14 | AF 9
    Servo S1 | TIM12 CH2 | PB 15 | AF 9
    Servo S2 | TIM1 CH1 | PE 9 | AF 1
    Servo S3 | TIM1 CH2 | PE 11 | AF 1
    Servo S4 | TIM1 CH3 | PE 13 | AF 1
    Servo S5 | TIM1 CH4 | PE 14 | AF 1

- ### Pyro Continuity Demultiplexer `DEMUX` CD 4051 B

    | Function | Description | GPIO | Pin Mode | Pin Type
    |-|-|-|-|-|
    MUX ENABLE | Multiplexer Enable | PC 0 | Output | Open Drain
    MUX A | Address Bit A | PC 13 | Output
    MUX B | Address Bit B | PC 14 | Output
    MUX C | Address Bit C | PC 15 | Output
    PYRO SENSE | Continuity ADC | PA 2 | Analog

- ### Micro SD `DATA`

    | Function | Description | GPIO | Pin Mode
    |-|-|-|-|
    SD CD | Card Detect | PD 1 | Input
    SD CLK | Clock | PB 2 | AF 12
    SD CMD | CMD | PD 2 | AF 12
    SD DAT 0 | Data Line 0 | PC 8 | AF 12
    SD DAT 1 | Data Line 1 | PB 0 | AF 12
    SD DAT 2 | Data Line 2 | PB 1 | AF 12
    SD DAT 3 | Data Line 3 | PC 11 | AF 12

- ### Flash `STORAGE`

    | Function | Description | GPIO | Pin Mode
    |-|-|-|-|
    Flash CLK | QuadSPI CLK | PD 3 | AF 9
    Flash CS | QuadSPI BK1 NCS | PB 6 | AF 10
    Flash IO0 | QuadSPI BK1 IO0 | PD 11 | AF 9
    Flash IO2 | QuadSPI BK1 IO2 | PE 2 | AF 9
    Flash IO1 | QuadSPI BK1 IO1 | PD 12 | AF 9
    Flash IO3 | QuadSPI BK1 IO3 | PD 13 | AF 9

- ### SWD `DEBUG`

    | Function | Description | GPIO | Pin Mode
    |-|-|-|-|
    SYS SW DIO | SYS JTMS SWDIO | PA 13 | AF 0
    SYS SW CLK | SYS JTCK SWCLK | PA 14 | AF 0

- ### USB `USB OTG FS`

    | Function | Description | GPIO | Pin Mode |
    |-|-|-|-|
    D- | USB OTG FS DM | PA 11 | AF 10
    D+ | USB OTG FS DP | PA 12 | AF 10

- ### LEDs and Buzzer `STATUS`

    | Function | GPIO | Pin Mode |
    |-|-|-|
    Buzzer | PD 0 | Output
    LED 1 | PD 4 | Output
    LED 2 | PD 5 | Output
    LED 3 | PD 6 | Output
    LED 4 | PD 7 | Output

## KiCad design polaris.kicad_pcb

Parts:
H101, H102, H103, H104: MountingHole_Pad; MountingHole_2.5mm_Pad_Via
J101: XT60-M; AMASS_XT60-F_1x02_P7.20mm_Vertical; PARTREV V1.2
J102: SPI; TerminalBlock_Xinya_XY308-2.54-4P_1x04_P2.54mm_Horizontal
J103: I2C; TerminalBlock_Xinya_XY308-2.54-2P_1x02_P2.54mm_Horizontal
J104: PB; TerminalBlock_Xinya_XY308-2.54-3P_1x03_P2.54mm_Horizontal
J105: SWD; TerminalBlock_Xinya_XY308-2.54-4P_1x04_P2.54mm_Horizontal
J106: PYRO0; TerminalBlock_Xinya_XY308-2.54-2P_1x02_P2.54mm_Horizontal
J107: PYRO1; TerminalBlock_Xinya_XY308-2.54-2P_1x02_P2.54mm_Horizontal
J108: PYRO2; TerminalBlock_Xinya_XY308-2.54-2P_1x02_P2.54mm_Horizontal
J109: PYRO3; TerminalBlock_Xinya_XY308-2.54-2P_1x02_P2.54mm_Horizontal
J110: PYRO4; TerminalBlock_Xinya_XY308-2.54-2P_1x02_P2.54mm_Horizontal
J111: PYRO5; TerminalBlock_Xinya_XY308-2.54-2P_1x02_P2.54mm_Horizontal
J112: SERVO0; TerminalBlock_Xinya_XY308-2.54-3P_1x03_P2.54mm_Horizontal
J113: SERVO1; TerminalBlock_Xinya_XY308-2.54-3P_1x03_P2.54mm_Horizontal
J114: SERVO2; TerminalBlock_Xinya_XY308-2.54-3P_1x03_P2.54mm_Horizontal
J115: SERVO3; TerminalBlock_Xinya_XY308-2.54-3P_1x03_P2.54mm_Horizontal
J116: SERVO4; TerminalBlock_Xinya_XY308-2.54-3P_1x03_P2.54mm_Horizontal
J117: SERVO5; TerminalBlock_Xinya_XY308-2.54-3P_1x03_P2.54mm_Horizontal
J118: RADIO; JST_XH_B4B-XH-A_1x04_P2.50mm_Vertical
J119, J121, J122: POWER; TerminalBlock_Xinya_XY308-2.54-2P_1x02_P2.54mm_Horizontal
J120: GNSS; JST_XH_B4B-XH-A_1x04_P2.50mm_Vertical
R101: 0R; R_0603_1608Metric; not fitted

Connections:
+3.3V: J105.4, J118.4, J119.1, J120.4, J121.1, J122.1; also elsewhere on the board
/3_NavigationProcessor/GNSS_RX: J120.3; also elsewhere on the board
/3_NavigationProcessor/GNSS_TX: J120.2; also elsewhere on the board
/3_NavigationProcessor/I2C2_SCL: J103.1; also elsewhere on the board
/3_NavigationProcessor/I2C2_SDA: J103.2; also elsewhere on the board
/3_NavigationProcessor/PB3: J104.1; also elsewhere on the board
/3_NavigationProcessor/PB4: J104.2; also elsewhere on the board
/3_NavigationProcessor/PB5: J104.3; also elsewhere on the board
/3_NavigationProcessor/RF_RX: J118.2; also elsewhere on the board
/3_NavigationProcessor/RF_TX: J118.3; also elsewhere on the board
/3_NavigationProcessor/SERVO_S0: J112.1; also elsewhere on the board
/3_NavigationProcessor/SERVO_S1: J113.1; also elsewhere on the board
/3_NavigationProcessor/SERVO_S2: J114.1; also elsewhere on the board
/3_NavigationProcessor/SERVO_S3: J115.1; also elsewhere on the board
/3_NavigationProcessor/SERVO_S4: J116.1; also elsewhere on the board
/3_NavigationProcessor/SERVO_S5: J117.1; also elsewhere on the board
/3_NavigationProcessor/SPI4_MISO: J102.3; also elsewhere on the board
/3_NavigationProcessor/SPI4_MOSI: J102.4; also elsewhere on the board
/3_NavigationProcessor/SPI4_NSS: J102.2; also elsewhere on the board
/3_NavigationProcessor/SPI4_SCK: R101.2; also elsewhere on the board
/3_NavigationProcessor/SYS_SWCLK: J105.3; also elsewhere on the board
/3_NavigationProcessor/SYS_SWDIO: J105.2; also elsewhere on the board
/4_Pyrochannels/PYRO_0: J106.2; also elsewhere on the board
/4_Pyrochannels/PYRO_1: J107.2; also elsewhere on the board
/4_Pyrochannels/PYRO_2: J108.2; also elsewhere on the board
/4_Pyrochannels/PYRO_3: J109.2; also elsewhere on the board
/4_Pyrochannels/PYRO_4: J110.2; also elsewhere on the board
/4_Pyrochannels/PYRO_5: J111.2; also elsewhere on the board
/4_Pyrochannels/SERVO_PWR: J112.2, J113.2, J114.2, J115.2, J116.2, J117.2; also elsewhere on the board
GND: H101.1 (1_1), H102.1 (1_1), H103.1 (1_1), H104.1 (1_1), J101.2 (NEG), J105.1, J112.3, J113.3, J114.3, J115.3, J116.3, J117.3, J118.1, J119.2, J120.1, J121.2, J122.2; also elsewhere on the board
unnamed: J102.1, R101.1
POWER: J106.1, J107.1, J108.1, J109.1, J110.1, J111.1; also elsewhere on the board
VBAT_VIN: J101.1 (POS); also elsewhere on the board

Notes on the sheet:
Pyrochannels
Servo Line 0
Servo Line 2
Servo Line 5
Servo Line 1
Battery Terminal
Possibly attach a 22-33 ohm resistor to reduce ringing (the layout is trash)
Servo Line 4
Servo Line 3

Parts:
C501: 2200u; CP_Radial_D13.0mm_P5.00mm
C502: 4u7; C_0805_2012Metric
D501: SMAJ9.0CA; D_SMA
J501: XT60-M; AMASS_XT60-F_1x02_P7.20mm_Vertical; PARTREV V1.2
Q501, Q502, Q503, Q504, Q505, Q506: IRLZ44N; TO-220-3_Vertical
R501, R502, R509, R510, R515, R516: 47R; R_0603_1608Metric
R503, R504, R505, R506, R507, R511, R512, R513, R514, R517, R518, R519, R520: 4k7; R_0603_1608Metric
R508: 1k; R_0603_1608Metric
U501, U502, U504, U505, U506, U507: PC817; DIP-4_W7.62mm
U503: CD4051B; SOIC-16_3.9x9.9mm_P1.27mm

Connections:
+3.3V: R507.1, U503.16 (VDD); also elsewhere on the board
+5V: U501.4, U502.4, U504.4, U505.4, U506.4, U507.4; also elsewhere on the board
/3_NavigationProcessor/MUX_A: U503.11 (A); also elsewhere on the board
/3_NavigationProcessor/MUX_B: U503.10 (B); also elsewhere on the board
/3_NavigationProcessor/MUX_C: U503.9 (C); also elsewhere on the board
/3_NavigationProcessor/PYRO_0: U501.1; also elsewhere on the board
/3_NavigationProcessor/PYRO_1: U502.1; also elsewhere on the board
/3_NavigationProcessor/PYRO_2: U504.1; also elsewhere on the board
/3_NavigationProcessor/PYRO_3: U505.1; also elsewhere on the board
/3_NavigationProcessor/PYRO_4: U506.1; also elsewhere on the board
/3_NavigationProcessor/PYRO_5: U507.1; also elsewhere on the board
/3_NavigationProcessor/PYRO_SENSE: R508.1, U503.3 (X); also elsewhere on the board
/3_NavigationProcessor/~MUX_EN: R507.2, U503.6 (INH); also elsewhere on the board
/4_Pyrochannels/PYRO_0: Q501.2 (D), R505.1; also elsewhere on the board
/4_Pyrochannels/PYRO_1: Q502.2 (D), R506.1; also elsewhere on the board
/4_Pyrochannels/PYRO_2: Q503.2 (D), R513.1; also elsewhere on the board
/4_Pyrochannels/PYRO_3: Q504.2 (D), R514.1; also elsewhere on the board
/4_Pyrochannels/PYRO_4: Q505.2 (D), R519.1; also elsewhere on the board
/4_Pyrochannels/PYRO_5: Q506.2 (D), R520.1; also elsewhere on the board
/4_Pyrochannels/PYRO_C0: R505.2, U503.12 (X3)
/4_Pyrochannels/PYRO_C1: R506.2, U503.13 (X0)
/4_Pyrochannels/PYRO_C2: R513.2, U503.14 (X1)
/4_Pyrochannels/PYRO_C3: R514.2, U503.15 (X2)
/4_Pyrochannels/PYRO_C4: R519.2, U503.1 (X4)
/4_Pyrochannels/PYRO_C5: R520.2, U503.5 (X5)
/4_Pyrochannels/SERVO_PWR: C501.1, C502.1, D501.2 (A2), J501.2 (NEG); also elsewhere on the board
GND: C501.2, C502.2, D501.1 (A1), Q501.3 (S), Q502.3 (S), Q503.3 (S), Q504.3 (S), Q505.3 (S), Q506.3 (S), R503.2, R504.2, R508.2, R511.2, R512.2, R517.2, R518.2, U501.2, U502.2, U503.7 (VEE), U503.8 (VSS), U504.2, U505.2, U506.2, U507.2; also elsewhere on the board
unnamed: Q501.1 (G), R501.1, R503.1
unnamed: Q502.1 (G), R502.1, R504.1
unnamed: Q503.1 (G), R509.1, R511.1
unnamed: Q504.1 (G), R510.1, R512.1
unnamed: Q505.1 (G), R515.1, R517.1
unnamed: Q506.1 (G), R516.1, R518.1
unnamed: R501.2, U501.3
unnamed: R502.2, U502.3
unnamed: R509.2, U504.3
unnamed: R510.2, U505.3
unnamed: R515.2, U506.3
unnamed: R516.2, U507.3
POWER: J501.1 (POS); also elsewhere on the board

Notes on the sheet:
Pyrochannel 2
Pyrochannel 1
Order of connections is wonky to help with routing PCB ¯\_(ツ)_/¯
Pyrochannel 3
Pyrochannel 5
Pyrochannel Continuity Sensing
Servo Power
Plug this with an XT60 short circuit cap in order to enable active stabilization. If at launch you are not confident in active stabilization (or believe something went wrong), please make sure to take out the short circuit cap and disable it entirely, so that your rocket can at least take off witho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
Pyrochannel 4
Pyrochannel 0
[5] PYRO
20 mA total

Parts:
BZ401: AC2208; AC1255
C401, C402: 20p; C_0603_1608Metric
C403: 1u; C_0603_1608Metric
C404, C405, C409, C410, C411, C412, C413, C414, C415, C416: 100n; C_0603_1608Metric
C406, C407: 2u2; C_0603_1608Metric
C408: 4u7; C_0805_2012Metric
D401, D402, D403, D404: GREEN; LED_0603_1608Metric
FB402: FerriteBead; L_0603_1608Metric
Q401: Q_NMOS; SOT-23
R401, R402: 4k7; R_0603_1608Metric
R403: 100k; R_0603_1608Metric
R404, R405, R408, R409: 180R; R_0603_1608Metric
R406: 47R; R_0603_1608Metric
R407: 47k; R_0603_1608Metric
R410: 22k1; R_0603_1608Metric
SW401, SW402: SW_Push; SW_SPST_TS-1088-xR020
U401: STM32F446VETx; LQFP-100_14x14mm_P0.5mm
Y401: YXC YSX321SL; Crystal_SMD_3225-4Pin_3.2x2.5mm

Connections:
+3.3V: C403.1, C404.1, C408.1, C409.1, C410.1, C411.1, C412.1, C413.1, C414.1, C415.1, FB402.2, R402.1, SW401.1, U401.6 (VBAT), U401.11 (VDD), U401.19 (VDD), U401.21 (VREF+), U401.28 (VDD), U401.50 (VDD), U401.75 (VDD), U401.100 (VDD); also elsewhere on the board
+5V: BZ401.1 (+); also elsewhere on the board
/1_Power/USB_VCC: R403.1; also elsewhere on the board
/2_USB/USB_D+: U401.71 (USB_OTG_FS_DP); also elsewhere on the board
/2_USB/USB_D-: U401.70 (USB_OTG_FS_DM); also elsewhere on the board
/3_NavigationProcessor/FLASH_CLK: U401.84 (QUADSPI_CLK); also elsewhere on the board
/3_NavigationProcessor/FLASH_CS: U401.92 (QUADSPI_BK1_NCS); also elsewhere on the board
/3_NavigationProcessor/FLASH_IO0: U401.58 (QUADSPI_BK1_IO0); also elsewhere on the board
/3_NavigationProcessor/FLASH_IO1: U401.59 (QUADSPI_BK1_IO1); also elsewhere on the board
/3_NavigationProcessor/FLASH_IO2: U401.1 (QUADSPI_BK1_IO2); also elsewhere on the board
/3_NavigationProcessor/FLASH_IO3: U401.60 (QUADSPI_BK1_IO3); also elsewhere on the board
/3_NavigationProcessor/GNSS_RX: U401.23 (UART4_TX); also elsewhere on the board
/3_NavigationProcessor/GNSS_TX: U401.24 (UART4_RX); also elsewhere on the board
/3_NavigationProcessor/I2C2_SCL: U401.47 (I2C2_SCL); also elsewhere on the board
/3_NavigationProcessor/I2C2_SDA: U401.80 (I2C2_SDA); also elsewhere on the board
/3_NavigationProcessor/ICM_CS: U401.29 (SPI1_NSS); also elsewhere on the board
/3_NavigationProcessor/ICM_INT: U401.26 (PA3); also elsewhere on the board
/3_NavigationProcessor/ICM_MISO: U401.32 (SPI1_MOSI); also elsewhere on the board
/3_NavigationProcessor/ICM_MOSI: U401.31 (SPI1_MISO); also elsewhere on the board
/3_NavigationProcessor/ICM_SCK: U401.30 (SPI1_SCK); also elsewhere on the board
/3_NavigationProcessor/LPS_INT: U401.68 (USB_OTG_FS_VBUS); also elsewhere on the board
/3_NavigationProcessor/LPS_SCL: U401.67 (I2C3_SCL); also elsewhere on the board
/3_NavigationProcessor/LPS_SDA: U401.66 (I2C3_SDA); also elsewhere on the board
/3_NavigationProcessor/LSM_INT: U401.51 (PB12); also elsewhere on the board
/3_NavigationProcessor/LSM_MISO: U401.17 (SPI2_MISO); also elsewhere on the board
/3_NavigationProcessor/LSM_MOSI: U401.16 (SPI2_MOSI); also elsewhere on the board
/3_NavigationProcessor/LSM_SCK: U401.52 (SPI2_SCK); also elsewhere on the board
/3_NavigationProcessor/MS_SCL: U401.95 (I2C1_SCL); also elsewhere on the board
/3_NavigationProcessor/MS_SDA: U401.93 (I2C1_SDA); also elsewhere on the board
/3_NavigationProcessor/MUX_A: U401.9 (PC15); also elsewhere on the board
/3_NavigationProcessor/MUX_B: U401.8 (PC14); also elsewhere on the board
/3_NavigationProcessor/MUX_C: U401.7 (PC13); also elsewhere on the board
/3_NavigationProcessor/NAV_BUZZ: R406.1, U401.81 (PD0)
/3_NavigationProcessor/NAV_STAT1: R404.1, U401.85 (PD4)
/3_NavigationProcessor/NAV_STAT2: R405.1, U401.86 (PD5)
/3_NavigationProcessor/NAV_STAT3: R408.1, U401.87 (PD6)
/3_NavigationProcessor/NAV_STAT4: R409.1, U401.88 (PD7)
/3_NavigationProcessor/OSC_IN: C401.1, U401.12 (RCC_OSC_IN), Y401.1
/3_NavigationProcessor/OSC_OUT: C402.1, U401.13 (RCC_OSC_OUT), Y401.3
/3_NavigationProcessor/PB3: U401.89 (PB3); also elsewhere on the board
/3_NavigationProcessor/PB4: U401.90 (PB4); also elsewhere on the board
/3_NavigationProcessor/PB5: U401.91 (PB5); also elsewhere on the board
/3_NavigationProcessor/PYRO_0: U401.63 (PC6); also elsewhere on the board
/3_NavigationProcessor/PYRO_1: U401.64 (PC7); also elsewhere on the board
/3_NavigationProcessor/PYRO_2: U401.61 (PD14); also elsewhere on the board
/3_NavigationProcessor/PYRO_3: U401.62 (PD15); also elsewhere on the board
/3_NavigationProcessor/PYRO_4: U401.56 (PD9); also elsewhere on the board
/3_NavigationProcessor/PYRO_5: U401.57 (PD10); also elsewhere on the board
/3_NavigationProcessor/PYRO_SENSE: U401.25 (PA2); also elsewhere on the board
/3_NavigationProcessor/RF_RX: U401.38 (UART5_RX); also elsewhere on the board
/3_NavigationProcessor/RF_TX: U401.39 (UART5_TX); also elsewhere on the board
/3_NavigationProcessor/SD_CD: U401.82 (PD1); also elsewhere on the board
/3_NavigationProcessor/SD_CLK: U401.37 (SDIO_CK); also elsewhere on the board
/3_NavigationProcessor/SD_CMD: U401.83 (SDIO_CMD); also elsewhere on the board
/3_NavigationProcessor/SD_DAT0: U401.65 (SDIO_D0); also elsewhere on the board
/3_NavigationProcessor/SD_DAT1: U401.35 (SDIO_D1); also elsewhere on the board
/3_NavigationProcessor/SD_DAT2: U401.36 (SDIO_D2); also elsewhere on the board
/3_NavigationProcessor/SD_DAT3: U401.79 (SDIO_D3); also elsewhere on the board
/3_NavigationProcessor/SERVO_S0: U401.54 (TIM12_CH2); also elsewhere on the board
/3_NavigationProcessor/SERVO_S1: U401.53 (TIM12_CH1); also elsewhere on the board
/3_NavigationProcessor/SERVO_S2: U401.40 (TIM1_CH1); also elsewhere on the board
/3_NavigationProcessor/SERVO_S3: U401.42 (TIM1_CH2); also elsewhere on the board
/3_NavigationProcessor/SERVO_S4: U401.44 (TIM1_CH3); also elsewhere on the board
/3_NavigationProcessor/SERVO_S5: U401.45 (TIM1_CH4); also elsewhere on the board
/3_NavigationProcessor/SPI4_MISO: U401.4 (SPI4_MISO); also elsewhere on the board
/3_NavigationProcessor/SPI4_MOSI: U401.5 (SPI4_MOSI); also elsewhere on the board
/3_NavigationProcessor/SPI4_NSS: U401.3 (SPI4_NSS); also elsewhere on the board
/3_NavigationProcessor/SPI4_SCK: U401.43 (SPI4_SCK); also elsewhere on the board
/3_NavigationProcessor/SYS_SWCLK: U401.76 (SYS_JTCK-SWCLK); also elsewhere on the board
/3_NavigationProcessor/SYS_SWDIO: U401.72 (SYS_JTMS-SWDIO); also elsewhere on the board
/3_NavigationProcessor/VBUS_DETECT: R403.2, R410.1, U401.77 (PA15)
/3_NavigationProcessor/~MUX_EN: U401.15 (PC0); also elsewhere on the board
GND: C401.2, C402.2, C403.2, C404.2, C405.1, C406.2, C407.2, C408.2, C409.2, C410.2, C411.2, C412.2, C413.2, C414.2, C415.2, C416.2, D401.1 (K), D402.1 (K), D403.1 (K), D404.1 (K), Q401.3 (D), R401.2, R407.2, R410.2, SW402.1, U401.10 (VSS), U401.20 (VSSA), U401.27 (VSS), U401.49 (VSS), U401.74 (VSS), U401.99 (VSS), Y401.2 (G), Y401.4 (G); also elsewhere on the board
unnamed: BZ401.2 (-), Q401.2 (S)
unnamed: D401.2 (A), R404.2
unnamed: D402.2 (A), R405.2
unnamed: D403.2 (A), R408.2
unnamed: D404.2 (A), R409.2
unnamed: Q401.1 (G), R406.2, R407.1
unnamed: R401.1, SW401.2, U401.94 (BOOT0)
unnamed: C405.2, R402.2, SW402.2, U401.14 (NRST)
unnamed: C406.1, U401.48 (VCAP_1)
unnamed: C407.1, U401.73 (VCAP_2)
unnamed: C416.1, FB402.1, U401.22 (VDDA)

Notes on the sheet:
12 pF load capacitance
[3] NAV
12 MHz Crystal (for USB)
Status LEDs for NAV
240 mA
Status Buzzer
To program the STM32, hold down SW401 and reset the MCU with SW402. Then, connect it to a computer via a regular USB-C cable.
QSPI: Flash SDIO: SD card SPI1: LSM6DSO32 SPI2: ICM-42688-P I2C1: MS5607 I2C3: LPS22HH UART4: GNSS Module UART5: LoRa Radio

Parts:
C201: 0u22; C_0603_1608Metric
C202: 10p; C_0603_1608Metric
C203, C204, C210, C212, C213, C215, C216, C219: 100n; C_0603_1608Metric
C205, C206: 4u7; C_0805_2012Metric
C207, C208, C209, C211, C214, C217, C218: 10u; C_0805_2012Metric
D201: GREEN; LED_0603_1608Metric
D202: ORANGE; LED_0603_1608Metric
L201, L202: 10u; L_Sunlord_SWPA8040S
Q201, Q202: IRLZ44N; TO-220-3_Vertical
R201: 360k; R_0603_1608Metric
R202: 47k; R_0603_1608Metric
R203: 0R1; R_2512_6332Metric
R204, R205: 180R; R_0603_1608Metric
R206: 162k; R_0603_1608Metric
R207, R209: 22.1k; R_0603_1608Metric
R208: 100k; R_0603_1608Metric
U201: BQ24005; HTSSOP-20-1EP_4.4x6.5mm_P0.65mm_EP3.4x6.5mm_Mask2.4x3.7mm
U202, U203: LM74700; SOT-23-6
U204, U205: LMR51430; SOT-23-6

Connections:
+3.3V: C211.1, C218.1, C219.1, L202.2, R204.2, R205.2, R208.1; also elsewhere on the board
+5V: C208.1, C213.1, C214.1, C215.1, C217.1, L201.2, R206.1, U204.3 (VIN), U204.5 (EN); also elsewhere on the board
/1_Power/3V3_CBOOT: C216.1, U204.6 (CB)
/1_Power/3V3_FB: R208.2, R209.1, U204.4 (FB)
/1_Power/3V3_SW: C216.2, L202.1, U204.2 (SW)
/1_Power/5V_CBOOT: C212.1, U205.6 (CB)
/1_Power/5V_FB: R206.2, R207.1, U205.4 (FB)
/1_Power/5V_SW: C212.2, L201.1, U205.2 (SW)
/1_Power/BATT_APG: R201.2, R202.1, U201.7 (APG/THERM)
/1_Power/CHG_STAT1: D202.2 (A), U201.14 (STAT1)
/1_Power/CHG_STAT2: D201.2 (A), U201.15 (STAT2)
/1_Power/IN: R203.2, U201.2 (IN), U201.3 (IN), U201.5 (ISNS), U201.17 (VSENSE)
/1_Power/USB_VCC: C204.1, Q202.3 (S), R201.1, R203.1, U201.4 (VCC), U201.8 (EN), U201.9 (VSEL), U203.3 (EN), U203.6 (ANODE); also elsewhere on the board
GND: C201.2, C205.2, C206.2, C207.2, C208.2, C209.2, C210.2, C211.2, C213.2, C214.2, C215.2, C217.2, C218.2, C219.2, R202.2, R207.2, R209.2, U201.10 (GND), U201.16 (AGND), U201.21 (GND), U202.2 (GND), U203.2 (GND), U204.1 (GND), U205.1 (GND); also elsewhere on the board
unnamed: D201.1 (K), R204.1
unnamed: D202.1 (K), R205.1
unnamed: Q201.1 (G), U202.5 (GATE)
unnamed: Q202.1 (G), U203.5 (GATE)
unnamed: C201.1, C202.1, U201.12 (CR)
unnamed: C202.2, U201.13 (TMR_SEL)
unnamed: C203.2, U202.1 (VCAP)
unnamed: C204.2, U203.1 (VCAP)
POWER: C205.1, C206.1, C207.1, C209.1, C210.1, Q201.2 (D), Q202.2 (D), U202.4 (CATHODE), U203.4 (CATHODE), U205.3 (VIN), U205.5 (EN); also elsewhere on the board
VBAT_VIN: C203.1, Q201.3 (S), U201.18 (OUT), U201.19 (OUT), U202.3 (EN), U202.6 (ANODE); also elsewhere on the board

Notes on the sheet:
Output inductor calculations: Lmin = (Vin_max - Vout) * Vout / Iout * K * Vin_max * f Vin_max = 5.5V, Vout = 3.3V, Iout = 1.5A, K = 0.3, f = 500kHz Lmin = ~5.9 uH. Choose nearest available 10 uH
5V Switching Rail
Main Power Rail
3V3 switching rail
Output inductor calculations: Lmin = (Vin_max - Vout) * Vout / Iout * K * Vin_max * f Vin_max = 9V, Vout = 5V, Iout = 2A, K = 0.3, f = 500kHz Lmin = ~7.4 uH. Choose nearest available 10 uH -------------------------------------------- Output capacitor calculations: ΔVout_esr = K * Iout * ESR = 30 mV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
Comparator voltage at FB = 0.6V typ. Choose R1 = 162k, R2 = 22.1k so that Vfb = 0.6V when Vout = 5V
[1] Power
Sets charge current to ~1A
Comparator voltage at FB = 0.6V typ. Choose R1 = 100k, R2 = 22.1k so that Vfb = 0.6V when Vout = 3.3V
Battery Charging Section
Please remember to keep the buck converters far from the USB-C receptacle to reduce EMI
Output capacitor calculations: ΔVout_esr = K * Iout * ESR = 30 mV max ⇒ ESR = 0.067 Ω max ΔVout_c = K * Iout / 8 * f * Cout = 30 mV max ⇒ Cout = 3.75 uF Cout > 4 * (Ioh - Iol) / f * ΔVout_shoot Using Ioh = 1.7A, Iol = 1.3A, ΔVout_shoot = 250 mV: Cout > 12.8 uF Using Cout > 12.8 uF at 50 mΩ ESR: Cho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
